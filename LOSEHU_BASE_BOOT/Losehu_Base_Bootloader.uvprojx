# Keil uVision project Losehu_Base_Bootloader.uvprojx, settings and files
target DP32G030 (6110000::V6.11::.\ARMCLANG)
  device: DP32G030 DP
  pack: DP.DP32_DFP.2.0.2
  cpu: IRAM(0x20000000,0x4000) IROM(0x00000000,0x10000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: LOSEHU_BASE_BOOTLOADER +hex
  AfterMake: fromelf --bin -o "$L@L.bin" "#L"
  c flags: Optim=7 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c include: .\CSL\CMSIS\CoreSupport;.\CSL\CMSIS\DeviceSupport;.\HARDWARE;.\CSL\DP32G030_StdPeriph_Driver
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x4000
  group APP
    ./APP/: main.c iap.c eeprom.c i2c.c
  group CSL\StdPD
    ./CSL/DP32G030_StdPeriph_Driver/: DP32G030_flash.c DP32G030_gpio.c DP32G030_port.c
  group CSL\CMSIS
    ./CSL/CMSIS/DeviceSupport/: system_DP32G030.c
    ./CSL/CMSIS/DeviceSupport/startup/arm/: startup_DP32G030.s
  group HARDWARE
    ./HARDWARE/: delay.c key.c
